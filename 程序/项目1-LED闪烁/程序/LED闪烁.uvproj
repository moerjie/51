# Keil uVision project LED闪烁.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: LED闪烁 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: F:\Keil_v5\C51\C51\INC
  group Source Group 1
    ./: main.c
